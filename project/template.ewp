# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\APP\inc; ..\Board\inc; ..\CMSIS\Libs; ..\Libraries\Drive\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/soc/: IRQ_Handler.c main.c
  group Board
    ../Board/soc/: ADC&DMA.c ANO_DT.c FFT.c LG_EncTPM.c Longer_motor.c LQ_LED.c Slide_average_filter.c task_scheduler.c
  group CMSIS
    ../CMSIS/Libs/: fsl_device_registers.h MK66F18.h
    ../CMSIS/Startup/: start.c startup_MK66F18.s
  group Libraries
    ../Libraries/Drive/soc/: fsl_clock.c fsl_common.c MK60_ADC.c MK60_CMT.c MK60_DMA.c MK60_FLASH.c MK60_FTM.c MK60_GPIO.c MK60_IIC.c MK60_LPTMR.c MK60_PIT.c MK60_PLL.c MK60_SYSTICK.c MK60_UART.c MK60_WDOG.c MK66_TPM.c
